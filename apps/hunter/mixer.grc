options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: chirp_rate
  id: variable
  parameters:
    value: 9.9951e4
  states: {}
- name: f0
  id: variable
  parameters:
    value: 6043612 * 1.5
  states: {}
- name: fn
  id: variable
  parameters:
    value: '''/media/rtse/Seagate Backup Plus Drive/Flash Drive/cubesat/new sh recordings/will not copy/IQREC-02-03-19-14h02m40s879.iq'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 20e6
    low_cutoff_freq: 1.5e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.25e6
    win: firdes.WIN_HAMMING
  states: {state: bypassed}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/rtse/Documents/cubesat/gr-chirphunter/data/out/sim_real.out
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '8.13'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: chirphunter_chirpgen_0
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate
    f0: f0
    samp_rate: samp_rate
  states: {state: disabled}
- name: chirphunter_chirpgen_1
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate
    f0: 'f0 '
    samp_rate: samp_rate
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '500'
    taps: '[1] * 500'
    type: ccc
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iqsource_1
  id: iqsource
  parameters:
    fn: fn
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 11e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {state: bypassed}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    grid: 'True'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    grid: 'True'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [chirphunter_chirpgen_0, '0', blocks_multiply_const_vxx_1, '0']
- [chirphunter_chirpgen_1, '0', blocks_conjugate_cc_0, '0']
- [fir_filter_xxx_1, '0', blocks_file_sink_1, '0']
- [iqsource_1, '0', band_pass_filter_0, '0']
- [iqsource_1, '0', blocks_complex_to_real_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
