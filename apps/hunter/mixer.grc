options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: chirp_rate
  id: variable
  parameters:
    value: 5e5
  states: {}
- name: f0
  id: variable
  parameters:
    value: 6.2885e6
  states: {}
- name: fn
  id: variable
  parameters:
    value: '''/home/rtse/Documents/cubesat/gr-chirphunter/data/in/IQREC-02-03-19-12h07m33s442.iq'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 20e6
    low_cutoff_freq: 1.5e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.25e6
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: chirphunter_chirpgen_0
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate
    f0: f0
    samp_rate: samp_rate
  states: {}
- name: chirphunter_chirpgen_1
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate
    f0: f0 * 1.5
    samp_rate: samp_rate
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iqsource_1
  id: iqsource
  parameters:
    fn: fn
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 11e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    grid: 'True'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [chirphunter_chirpgen_0, '0', blocks_add_xx_0, '1']
- [chirphunter_chirpgen_1, '0', blocks_conjugate_cc_0, '0']
- [iqsource_1, '0', band_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
