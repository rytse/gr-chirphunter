options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: chirp_rate
  id: variable
  parameters:
    value: 9.9951e4
  states: {}
- name: decim
  id: variable
  parameters:
    value: '500'
  states: {}
- name: f0
  id: variable
  parameters:
    value: '6043612'
  states: {}
- name: fn
  id: variable
  parameters:
    value: '''/media/rytse/Seagate Backup Plus Drive/Flash Drive/cubesat/new sh recordings/will not copy/IQREC-02-03-19-14h02m40s879.iq'''
  states: {state: disabled}
- name: fn
  id: variable
  parameters:
    value: '''/media/rytse/Seagate Backup Plus Drive/Flash Drive/cubesat/new sh recordings/will not copy/IQREC-02-03-19-12h31m01s566.iq'''
  states: {state: disabled}
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 50e6 / 100
    gain: '1.0'
    samp_rate: samp_rate
    width: 50e3
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '5000000'
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/vagrant/gr-chirphunter/data/out/real_nofilt_nodecim_adj.out
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: chirphunter_chirpgen_1
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate
    f0: f0 +29.7e6 + 49.3e6
    samp_rate: samp_rate
  states: {}
- name: chirphunter_hough_0
  id: chirphunter_hough
  parameters:
    fftlen: '4096'
    houghlen: '4096'
    nb: '10'
    ntheta: '10'
    sigma: '5'
    tmax: np.pi / 2
    tmin: '0'
  states: {}
- name: chirphunter_saw_0
  id: chirphunter_saw
  parameters:
    _buflen: '256'
    _fftlen: '1048576'
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iqsource_1
  id: iqsource
  parameters:
    fn: fn
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.1e6
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '1'
    size: '256'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    grid: 'True'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '1'
    taps: lpf
    type: ccc
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_1, '0', chirphunter_saw_0, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_0, '0']
- [chirphunter_chirpgen_1, '0', blocks_conjugate_cc_0, '0']
- [chirphunter_chirpgen_1, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_1, '0']
- [rational_resampler_xxx_0, '0', chirphunter_hough_0, '0']

metadata:
  file_format: 1
