options:
  parameters:
    author: Ryan Tse
    description: Generate two LFMs with a time offset, mix them, plot output
    generate_options: qt_gui
    id: sim_chirp
    output_language: python
    title: Simulate Chirp
  states: {}

blocks:
- name: chirp_rate
  id: variable
  parameters:
    value: 1.0085e5
  states: {}
- name: f0
  id: variable
  parameters:
    value: 6.2885e6
  states: {}
- name: mval
  id: variable_qtgui_range
  parameters:
    label: Mix Value (MHz)
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '30'
    value: '2.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: variable_1
  id: variable
  parameters:
    value: '''/home/rtse/Documents/cubesat/gr-chirphunter/data/in/IQREC-02-03-19-12h07m33s442.iq'''
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: mval * 1e6
    offset: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: chirphunter_chirpgen_0
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate
    f0: f0 * 1.7
    samp_rate: samp_rate
  states: {}
- name: chirphunter_chirpgen_2
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate *1.5
    f0: f0
    samp_rate: samp_rate
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_multiply_xx_2, '1']
- [blocks_complex_to_real_1, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_xx_2, '0', blocks_conjugate_cc_0, '0']
- [chirphunter_chirpgen_0, '0', blocks_multiply_xx_1, '0']
- [chirphunter_chirpgen_2, '0', blocks_conjugate_cc_0, '0']
- [chirphunter_chirpgen_2, '0', blocks_multiply_xx_2, '0']

metadata:
  file_format: 1
