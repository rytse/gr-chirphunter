options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: chirp_rate
  id: variable
  parameters:
    value: '100166.14948319287'
  states: {}
- name: f0
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '8192'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: short
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rtse/Documents/cubesat/gr-chirphunter/data/dmixed_iq.out
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rtse/Documents/cubesat/gr-chirphunter/data/target.out
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/rtse/Documents/cubesat/gr-chirphunter/data/target.iq
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_int_to_float_1
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '8192'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8192'
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '8192'
    type: float
  states: {}
- name: chirphunter_chirpgen_0
  id: chirphunter_chirpgen
  parameters:
    chirp_rate: chirp_rate
    f0: f0
    samp_rate: samp_rate
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '8192'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(8192)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '500'
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '1'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '100'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_deinterleave_0, '0', blocks_int_to_float_0, '0']
- [blocks_deinterleave_0, '0', blocks_short_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_int_to_float_1, '0']
- [blocks_deinterleave_0, '1', blocks_short_to_float_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_1, '0', blocks_deinterleave_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_int_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_int_to_float_1, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_0, '0']
- [chirphunter_chirpgen_0, '0', blocks_multiply_xx_0, '1']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
