options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: chirp_rate
  id: variable
  parameters:
    value: 1.0085e5
  states: {}
- name: f0
  id: variable
  parameters:
    value: 6.2885e6
  states: {}
- name: fn
  id: variable
  parameters:
    value: '''/home/rtse/Documents/cubesat/gr-chirphunter/data/in/IQREC-02-03-19-12h07m33s442.iq'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rtse/Documents/cubesat/gr-chirphunter/data/out/sim2.out
    type: complex
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '500'
    taps: '[1] * 500'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iqsource_0
  id: iqsource
  parameters:
    fn: fn
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"2x"'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '1'
    size: 1024*256
    srate: samp_rate
    type: float
    ymax: '10000'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_max_xx_0, '0']
- [blocks_max_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_max_xx_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [iqsource_0, '0', blocks_complex_to_mag_0, '0']
- [iqsource_0, '0', fir_filter_xxx_0, '0']
- [iqsource_0, '0', qtgui_sink_x_2, '0']

metadata:
  file_format: 1
