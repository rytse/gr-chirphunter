<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>50e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whiten_len</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>whiten_n</value></param>
<param><key>value</key><value>30000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/rtse/Documents/cubesat/gr-lfmr/data/target.out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>32e3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>juha_chirp_downconvert</key>
<param><key>id</key><value>juha_chirp_downconvert_0</value></param>
</block>
<block>
<key>juha_whiten</key>
<param><key>id</key><value>juha_whiten_0</value></param>
<param><key>navg</key><value>whiten_n</value></param>
<param><key>nfft</key><value>whiten_len</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>juha_whiten_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>juha_whiten_0</source_block_id><sink_block_id>juha_chirp_downconvert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
