options:
  parameters:
    author: Ryan Tse
    description: File source for SignalHound IQ data (complex interleaved int16s)
    generate_options: hb
    id: iqsource
    output_language: python
    title: IQ Source
  states: {}

blocks:
- name: blocks_deinterleave_1
  id: blocks_deinterleave
  parameters:
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: fn
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: fn
  id: parameter
  parameters:
    label: File Name
    type: str
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}

connections:
- [blocks_deinterleave_1, '0', blocks_short_to_float_1, '0']
- [blocks_deinterleave_1, '1', blocks_short_to_float_0, '0']
- [blocks_file_source_0, '0', blocks_deinterleave_1, '0']
- [blocks_float_to_complex_1, '0', pad_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_1, '1']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_1, '0']

metadata:
  file_format: 1
